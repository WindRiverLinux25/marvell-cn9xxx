require linux-yocto-marvell-cn96xx.inc

KBRANCH:marvell-cn96xx = "v6.12/standard/octeon"
